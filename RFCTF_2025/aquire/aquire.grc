options:
  parameters:
    generate_options: qt_gui
    id: aquire
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: filename
  id: variable
  parameters:
    value: '"out.bin"'
  states: {}
- name: ip
  id: variable
  parameters:
    value: '"sdr.rfhackers.com"'
  states: {}
- name: port
  id: variable
  parameters:
    value: '"6563"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '96000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: filename
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"RX from " + ip + ":" + port'
    type: complex
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: '"tcp://"+ip+":"+port'
    timeout: '100'
    type: complex
  states: {}

connections:
- [zeromq_sub_source_0, '0', blocks_file_sink_0, '0']
- [zeromq_sub_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
