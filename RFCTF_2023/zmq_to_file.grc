options:
  parameters:
    author: Corey
    generate_options: qt_gui
    id: zmq_nbfm_rx
    output_language: python
    title: ZMQ NBFM Receiver
  states: {}

blocks:
- name: filename
  id: variable
  parameters:
    value: '"morse3.bin"'
  states: {}
- name: ip
  id: variable
  parameters:
    value: '"sdr.rfhackers.com"'
  states: {}
- name: port
  id: variable
  parameters:
    value: '"6566"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '96000'
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: filename
    type: complex
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"RX from " + ip + ":" + port'
    showports: 'True'
    type: complex
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: '"tcp://"+ip+":"+port'
    timeout: '100'
    type: complex
  states: {}

connections:
- [zeromq_sub_source_0, '0', blocks_file_sink_0_0, '0']
- [zeromq_sub_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
